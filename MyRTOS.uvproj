# Keil uVision project MyRTOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MyRTOS +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\APP;.\BSP;.\CMSIS;.\LIB\inc;.\OS;.\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c
  group LIB
    ./LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group OS
    ./OS/: MyRTOS.c STM_CPU.asm
  group BSP
    ./BSP/: bsp.c led.c
  group APP
    ./APP/: app.c
